# IAR project mfb_fw_cm33_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT798S_M33_0 NXP MIMXRT798S_M33_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOA_cm33_core0; BOOT_HEADER_ENABLE=1
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../src; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT798S; ../../../../../../devices/MIMXRT798S/periph; ../../../../../../devices/MIMXRT798S/drivers; ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../components/uart
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT798SGFOA_cm33_core0
  AARM.AUserIncludes: ..; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT798S; ../../../../../../devices/MIMXRT798S/periph; ../../../../../../devices/periph; ../../../../../../devices/MIMXRT798S/drivers; ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../components/uart
  OBJCOPY.OOCOutputFile: hello_world.bin
  ILINK.IlinkOutputFile: hello_world_cm33_core0.out
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 58
  ICCARM.CCIncludePath2: ..; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT798S; ../../../../../../devices/MIMXRT798S/periph; ../../../../../../devices/MIMXRT798S/drivers; ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../components/uart
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
configuration release (ARM)
  as the first configuration, except:
  General.CoreVariant: 58
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOA_cm33_core0; BOOT_HEADER_ENABLE=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
configuration flash_release (ARM)
  as the first configuration, except:
  General.CoreVariant: 58
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
  group board
    ../: app.h board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h port_mixspi_info.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: armv8m_mpu.h cmsis_iccarm_m.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LP_FLEXCOMM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group drivers
    ../../../../../../devices/MIMXRT798S/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_glikey.c fsl_glikey.h fsl_gpio.c fsl_gpio.h fsl_iopctl.h fsl_lpflexcomm.c fsl_lpflexcomm.h fsl_lpuart.c fsl_lpuart.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_xspi.c fsl_xspi.h
  group flash_config
    ../../../../flash_config/: evkmimxrt798_flash_config.c evkmimxrt798_flash_config.h
  group source
    ../: main.c mcux_config.h
    ../../../src/: mfb.c mfb.h mfb_adapter.h mfb_config.h mfb_define.h mfb_nor_flash.c mfb_nor_flash.h mfb_nor_flash_adesto.c mfb_nor_flash_adesto.h mfb_nor_flash_gigadevice.c mfb_nor_flash_gigadevice.h mfb_nor_flash_issi.c mfb_nor_flash_issi.h mfb_nor_flash_micron.c mfb_nor_flash_micron.h mfb_nor_flash_mxic.c mfb_nor_flash_mxic.h mfb_nor_flash_spansion.c mfb_nor_flash_spansion.h mfb_nor_flash_winbond.c mfb_nor_flash_winbond.h mfb_nor_ops_xspi.c microseconds_common.c microseconds_cortexm_systick.c
  group startup/iar
    ../../../../../../devices/MIMXRT798S/iar/: startup_MIMXRT798S_cm33_core0.s
  group utilities
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_assert.c fsl_assert.h
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities/str
    ../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.c fsl_str.h
