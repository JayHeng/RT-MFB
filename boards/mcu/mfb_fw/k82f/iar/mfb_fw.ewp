# IAR project mfb_fw.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK82FN256xxx15 NXP MK82FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK82FN256VLL15; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; FRDM_K82F; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../src; ../../../../../CMSIS/Core/Include; ../../../../../devices; ../../../../../devices/MK82F25615/drivers; ../../../../../devices/MK82F25615; ../../../../../devices/MK82F25615/utilities/str; ../../../../../devices/MK82F25615/utilities/debug_console; ../../../../../components_v2.8/uart; ../../../../../components_v2.8/serial_manager; ../../../../../components_v2.8/lists; ../../../../../devices/MK82F25615/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MK82FN256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK82FN256VLL15; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; FRDM_K82F; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Core/Include; ../../../../../devices; ../../../../../devices/MK82F25615/drivers; ../../../../../devices/MK82F25615; ../../../../../devices/MK82F25615/utilities/str; ../../../../../devices/MK82F25615/utilities/debug_console; ../../../../../components_v2.8/uart; ../../../../../components_v2.8/serial_manager; ../../../../../components_v2.8/lists; ../../../../../devices/MK82F25615/utilities
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h port_mixspi_info.h
  group CMSIS
    ../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group component_v2.8/lists
    ../../../../../components_v2.8/lists/: generic_list.c generic_list.h
  group component_v2.8/serial_manager
    ../../../../../components_v2.8/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component_v2.8/uart
    ../../../../../components_v2.8/uart/: lpuart_adapter.c uart.h
  group device
    ../../../../../devices/MK82F25615/: fsl_device_registers.h MK82F25615.h MK82F25615_features.h system_MK82F25615.c system_MK82F25615.h
  group drivers
    ../../../../../devices/MK82F25615/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_qspi.c fsl_qspi.h fsl_smc.c fsl_smc.h
  group source
    ../: main.c
    ../../src/: mfb_adapter.h mfb_config.h mfb_define.h mfb_nor_ops_quadspi.c quadspi_polling_transfer.c
  group startup
    ../../../../../devices/MK82F25615/iar/: startup_MK82F25615.s
  group utilities
    ../../../../../devices/MK82F25615/utilities/: fsl_assert.c
    ../../../../../devices/MK82F25615/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK82F25615/utilities/str/: fsl_str.c fsl_str.h
